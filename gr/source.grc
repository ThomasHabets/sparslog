options:
  parameters:
    author: Thomas Habets <thomas@habets.se>
    generate_options: no_gui
    id: source
    output_language: python
    title: Sparsnäs source
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: igain
  id: parameter
  parameters:
    value: '30'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: igain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', network_tcp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
