options:
  parameters:
    author: thompa
    generate_options: qt_gui
    id: decode
    output_language: python
    title: IKEA Sparsnas
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '38383.5'
  states: {}
- name: ofs
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '-10000'
  states: {}
- name: raw_samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-samp_rate/baud'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-samp_rate/baud'
    type: float
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: b200-868M-1024k-ofs-1s.c32
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: b200-868M-1024k-ofs.c32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '100'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1010101010101010110100100000000100010001'
    tagname: packet
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 10*2*3.14/100
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/baud
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt

      PACKETLEN = 0x12 * 8

      # other base classes are basic_block, decim_block, interp_block
      class blk(gr.sync_block):
          """Take a fixed amount of bits and stuff into a PDU."""

          def __init__(self, packetlen=0x12*8):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Packet pickup',
                  in_sig=[np.byte],
                  out_sig=[]
              )
              self._out = pmt.intern("pdu")
              self._packet = []
              self._packetlen = packetlen
              self.message_port_register_out(self._out)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if len(self._packet):
                  need = self._packetlen-len(self._packet)
                  self._packet.extend(input_items[0][:need])
                  if len(self._packet) < self._packetlen:
                      return need
                  msg = pmt.cons(pmt.PMT_NIL,
                                 pmt.init_u8vector(len(self._packet), self._packet))
                  self.message_port_pub(self._out, msg)
                  self._packet = []
                  return need
                  
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              tags = [x for x in tags if pmt.to_python(x.key)=='packet']
              if not tags:
                  return len(input_items[0])

              ofs = tags[0].offset - self.nitems_read(0)
              if ofs > 0:
                  return ofs
              self._packet = list(input_items[0][:self._packetlen])
              return len(self._packet)
    packetlen: (0x11+2)*8
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      """

      import time
      import numpy as np
      from gnuradio import gr
      from gnuradio.gr import pmt


      class blk(gr.sync_block):
          """Block to take packets and write to files."""

          def __init__(self):
              """Init."""
              gr.sync_block.__init__(
                  self,
                  name='Packet saver',
                  in_sig=[],
                  out_sig=[]
              )
              self._in = pmt.intern("pdu")
              self.message_port_register_in(self._in)
              self.set_msg_handler(self._in, self.handle_msg)

          def handle_msg(self, msg):
              data = pmt.to_python(pmt.cdr(msg))
              bs = bytes(data)
              open('packets/%s' % time.time(), 'wb').write(bs)
              #print('saving bytes!', data, len(bs), len(data))

          def work(self, input_items, output_items):
              """dummy."""
              return len(output_items[0])
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: ofs
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate/2,10)
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 0,1
    name: '"Burst"'
    size: samp_rate//100
    srate: samp_rate
    tr_delay: '2e-3'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"burst"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 0,0
    label1: I
    label2: Q
    label3: Burst signal
    name: '"Trigger"'
    nconnections: '3'
    size: samp_rate//100
    srate: samp_rate
    tr_delay: '2e-3'
    tr_level: '0.001'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"burst"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 1,0
    size: samp_rate//100
    srate: samp_rate
    tr_delay: '2e-3'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 1,1
    label1: Symbols
    label2: Error
    label3: T inst
    label4: T avg
    marker1: '0'
    nconnections: '4'
    size: int(baud/100)
    srate: baud
    tr_delay: '2e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,0,1,2
    label1: Symbols
    marker1: '0'
    name: '"Bits"'
    size: int(baud/100)
    srate: baud
    tr_delay: '2e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet"'
    type: float
    ymax: '2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: raw_samp_rate
    interp: samp_rate
    type: ccc
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '10e-2'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_1, '3']
- [blocks_burst_tagger_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_burst_tagger_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_0_0, '1']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0, '0', blocks_burst_tagger_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_1, '1']
- [digital_symbol_sync_xx_0, '2', blocks_add_const_vxx_0, '0']
- [digital_symbol_sync_xx_0, '3', blocks_add_const_vxx_0_0, '0']
- [epy_block_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]
- [freq_xlating_fft_filter_ccc_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_pack_k_bits_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_1, pdu]
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [rational_resampler_xxx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_float_to_short_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
