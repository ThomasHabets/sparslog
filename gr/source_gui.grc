options:
  parameters:
    author: Thomas Habets <thomas@habets.se>
    generate_options: qt_gui
    id: source_gui
    output_language: python
    title: Sparsnäs source GUI
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: igain
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/thompa/scm/rustradio/several.c32
    type: complex
  states: {state: disabled}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: samp_rate//100
    srate: samp_rate
    tr_delay: '1e-3'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: '200000'
    type: ccc
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: igain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [rational_resampler_xxx_0, '0', network_tcp_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', network_tcp_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
